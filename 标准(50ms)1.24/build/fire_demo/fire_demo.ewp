# IAR project fire_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\app_image; ..\..\src\app_mydriver\platforms; ..\..\src\app_mydriver; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\sdhc; ..\..\src\drivers\w25x16; ..\..\src\drivers\Flash; ..\..\src\drivers\dac; ..\..\src\drivers\adc; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\timer; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\drivers\port; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build; ..\..\build\fire_demo; ..\..\build\fire_demo\Debug; ..\..\build\fire_demo\Debug\Obj; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG; ..\..\src\drivers\spi; ..\..\src\drivers; ..\..\src\drivers\i2c; ..\..\src\drivers\key; ..\..\src\drivers\BEEP; ..\..\src\drivers\dial_switch; ..\..\src\drivers\PWM; ..\..\src\drivers\getspeed; ..\..\src\drivers\LCD; ..\..\src\drivers\PID; ..\..\src\drivers\camera; ..\..\src\drivers\image_process; ..\..\src\drivers\LDC1314; ..\..\src\drivers\LDC1000; ..\..\src\drivers\cmt; ..\..\src\drivers\filter; ..\..\src\drivers\number
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\app_image; ..\..\src\app_mydriver; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\sdhc; ..\..\src\drivers\w25x16; ..\..\src\drivers\Flash; ..\..\src\drivers\dac; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\timer; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\drivers\port; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\NRF; ..\..\build; ..\..\build\fire_demo; ..\..\build\fire_demo\Debug; ..\..\build\fire_demo\Debug\Obj; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG; ..\..\src\drivers\MPU6050; ..\..\src\drivers\MPU6050\eMPL; ..\..\src\drivers; ..\..\src\drivers\i2c; ..\..\src\drivers\LCD; ..\..\src\drivers\spi; ..\..\src\drivers\dial_switch; ..\..\src\drivers\key; ..\..\src\drivers\BEEP; ..\..\src\drivers\getspeed; ..\..\src\drivers\PWM; ..\..\src\drivers\PID
  group app
    ../../src/app/: Car_init.c define.c define.h include.h isr.c isr.h ISR_FUN.c main.c mymath.c
    ../../src/drivers/: fire_drivers_cfg.h
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c vectors.h
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/number/: atk_ncr.c
    ../../src/drivers/BEEP/: beep.c
    ../../src/drivers/cmt/: cmt.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dial_switch/: dial_switch.c
    ../../src/drivers/dma/: dma.c dma.h
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/filter/: filter.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/getspeed/: getspeed.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c i2c.h i2c_cfg.h
    ../../src/drivers/image_process/: image_process.c
    ../../src/drivers/LCD/: LCD.c
    ../../src/drivers/LDC1000/: ldc1000.c
    ../../src/drivers/LDC1314/: ldc1314.c ldc1314iic.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/spi/: MK60_spi.c
    ../../src/drivers/key/: mykey.c
    ../../src/drivers/PWM/: myPWM.c
    ../../src/drivers/camera/: OV7725.c SCCB.c
    ../../src/drivers/PID/: pid.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/port/: port.c port.h
    ../../src/drivers/sdhc/: sdhc.c sdhc.h
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/app_mydriver/: k60_fire.h
    ../../src/cpu/headers/: MK60DZ10.h
  group header/CMSIS
    ../../src/LIB/CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h iar_cortexM4l_math.a
